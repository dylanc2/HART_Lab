Commit message: Add edge tracking

File: iiwa14.urdf (robot description, URDF)
Before this commit: robot iiwa14, 11 links, 10 joints
Joints:
- joint tool_tip_joint: origin xyz=0 0 0.24 rpy=0 0 0 -> xyz=0 0 0.20 rpy=0 0 0
